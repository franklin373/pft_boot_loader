# IAR project P50_BootLoader.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\include; ..\drv\SysSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: P50_BootLoader.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\linker\ldscript_iram_iar.icf
  group app_main
    ../app/main/: app_main.c
  group drv_clkpwr
    ../drv/clkpwr/: lpc177x_8x_clkpwr.c
  group drv_pin
    ../drv/pin/: lpc177x_8x_pinsel.c
  group drv_startup
    ../drv/startup/: startup_LPC177x_8x.s
  group drv_SysSupport
    ../drv/SysSupport/: core_cm3.c system_LPC177x_8x.c
  group drv_uart
    ../drv/uart/: lpc177x_8x_uart.c
